#

SRC_URI:remove = "git://github.com/vim/vim.git;branch=master;protocol=https"
SRC_URI:append = " ${CODEWEBSITE}/vim;branch=master;protocol=https"
