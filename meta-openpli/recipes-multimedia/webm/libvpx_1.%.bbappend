
SRC_URI:remove = "git://chromium.googlesource.com/webm/libvpx;protocol=https;branch=main"
SRC_URI:append = " ${CODEWEBSITE}/libvpx;protocol=https;branch=main"
