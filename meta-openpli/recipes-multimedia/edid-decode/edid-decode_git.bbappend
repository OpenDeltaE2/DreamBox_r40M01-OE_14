SRC_URI = "git://gitcode.com/jack2015/edid-decode.git;protocol=https;branch=master"
