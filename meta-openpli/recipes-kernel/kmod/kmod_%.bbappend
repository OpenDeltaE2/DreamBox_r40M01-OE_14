# Copyright (C) 2012 Khem Raj <raj.khem@gmail.com>
# Released under the MIT license (see COPYING.MIT for the terms)


SRC_URI:remove = "git://git.kernel.org/pub/scm/utils/kernel/kmod/kmod.git;branch=master;protocol=https"
SRC_URI:append = " ${CODEWEBSITE}/kmod.git;branch=master;protocol=https "
